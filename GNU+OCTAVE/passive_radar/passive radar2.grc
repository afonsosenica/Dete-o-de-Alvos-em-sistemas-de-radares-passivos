options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: Passive Radar
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: sample_fft
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: uirange
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '700000000'
    step: '1'
    stop: '800000000'
    value: '754000000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: sample_fft
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: mag.dat
    type: float
    vlen: sample_fft
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: signal.dat
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: sample_fft
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: sample_fft
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: sample_fft
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: sample_fft
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: sample_fft
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: complex
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: sample_fft
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: sample_fft
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_2
  id: fft_vxx
  parameters:
    fft_size: sample_fft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    clock_source0: gpsdo
    freq0: uirange
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: '8000000'
    fc: uirange
    fftsize: sample_fft
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '5000000'
    ymin: '-5000000'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"vector_sink"'
    vlen: sample_fft
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '8000000'
    fc: '0'
    fftsize: sample_fft
    int_max: '50'
    int_min: '0'
    type: complex
    update_time: '0.20'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_file_sink_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_2, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_1, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_freq_sink_x_2, '0']
- [blocks_vector_to_stream_1, '0', qtgui_time_sink_x_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_1, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_1, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_2, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_2, '0', blocks_vector_to_stream_1, '0']
- [osmosdr_source_0, '0', blocks_file_sink_1, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_1, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
